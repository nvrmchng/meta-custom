FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PR_append = ".arago1"

